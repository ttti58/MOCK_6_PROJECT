# IAR project MOCK UART.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: D:\Hoc Tap\FPT Intern\MOCK_PROJECT_6\MyLib\src; D:\Hoc Tap\FPT Intern\MOCK_PROJECT_6\MyLib\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MOCK UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Project/: main.c
  group MyLib/inc
    MyLib/inc/: GPIO.h stm8l_define.h
  group MyLib/src
    MyLib/src/: GPIO.c stm8l_define.c
